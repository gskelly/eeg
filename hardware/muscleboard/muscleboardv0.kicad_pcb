# Repository gskelly/eeg (continued)

## KiCad design hardware/brainboard/brainboardv1/brainboardv1.kicad_pcb

Parts:
P1: WP
P5: GND
P7: 3V3
R1, R2, R3: 4.7K
R4: 10K
R5, R6: 5.6K
S2: SMT_BUTTON
SJ4: A2; SparkFun-Passives-SJ_2S-NOTRACE
SJ5: A1; SparkFun-Passives-SJ_2S-NOTRACE
U1: 24C256
U2: BEAGLEBONE_BLACK

Connections:
+3.3V: P7.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.8 (VCC), U2.B3 (VDD_3V3B), U2.B4 (VDD_3V3B); also elsewhere on the board
/A0: R3.2, U1.1 (A0)
/A1: R2.2, SJ5.1, U1.2 (A1)
/A2: R1.2, SJ4.1, U1.3 (A2)
/CS_DAISY: U2.B42 (GPIO0_7); also elsewhere on the board
/CS_MAIN: U2.B28 (SPI1_CS0); also elsewhere on the board
/DRDY: U2.B25 (GPIO3_21); also elsewhere on the board
/PWDN: U2.A23 (MMC1_DAT4); also elsewhere on the board
/WP: P1.1, R4.2, U1.7 (WP)
AGND: P5.1, S2.1, S2.3, SJ4.2, SJ5.2, U1.4 (GND), U2.A1 (DGND), U2.A2 (DGND), U2.B1 (DGND), U2.B2 (DGND), U2.B34 (GNDA_ADC), U2.B43 (DGND), U2.B44 (DGND), U2.B45 (DGND), U2.B46 (DGND); also elsewhere on the board
CLK: U2.A25 (MMC1_DAT0); also elsewhere on the board
I2C2_SCL: R5.2, U1.6 (SCL), U2.B21 (MMC1_CLK); also elsewhere on the board
I2C2_SDA: R6.2, U1.5 (SDA), U2.B22 (UART2_RXD); also elsewhere on the board
MISO: U2.B30 (SPI1_D1); also elsewhere on the board
MOSI: U2.B29 (SPI1_D0); also elsewhere on the board
unnamed: S2.2, S2.4, U2.B9 (PWR_BUT)
SCLK: U2.B31 (SPI1_SCLK); also elsewhere on the board
UARTBT_CTS: U2.B20 (I2C2_SDA); also elsewhere on the board
UARTBT_RTS: U2.B19 (I2C2_SCL); also elsewhere on the board
UARTBT_RX: U2.B26 (UART1_RXD); also elsewhere on the board
UARTBT_TX: U2.B24 (UART1_TXD); also elsewhere on the board
UARTUC_RX: U2.B13 (UART4_TXD); also elsewhere on the board
UARTUC_TX: U2.B11 (UART4_RXD); also elsewhere on the board

Notes on the sheet:
I2C serial EEPROM for board ID
If using MCU for Bluetooth communications, make sure BBB UART1 RX/TX/RTS/CTS are configured as inputs to prevent bus contention!
UART2_TXD/RXD mux config to MODE2 (I2C2_SCL/SDA), I2C2_SCL/SDA mux config to MODE0 (UART1_RTSN/CTSN)
UARTBT on BBB UART1 (w/ HW flow control), UARTUC on BBB UART4 (no flow control)

Parts:
C17, C18, C19: 0.1uF
C20, C21, C22, C23, C24, C25, C26, C27, C28, C55, C56: 4.7nF
P2: CONN_14
R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 4.99K
U5, U6, U7: TPD4E001DBV

Connections:
+2.5V: C17.1, C18.1, C19.1, U5.5 (VCC), U6.5 (VCC), U7.5 (VCC); also elsewhere on the board
-2.5V: C17.2, C18.2, C19.2, U5.2 (GND), U6.2 (GND), U7.2 (GND); also elsewhere on the board
/BrainBoard Analog In/BIAS_ELEC: P2.12, R12.1, U7.3 (IO2)
/BrainBoard Analog In/BIAS_SHD: P2.13, R11.1
/BrainBoard Analog In/CH1ELEC_N: P2.2, R22.1, U5.6 (IO4)
/BrainBoard Analog In/CH1ELEC_P: P2.1, R23.1, U5.4 (IO3)
/BrainBoard Analog In/CH2ELEC_N: P2.4, R20.1, U5.3 (IO2)
/BrainBoard Analog In/CH2ELEC_P: P2.3, R21.1, U5.1 (IO1)
/BrainBoard Analog In/CH3ELEC_P: P2.5, R19.1, U6.4 (IO3)
/BrainBoard Analog In/CH4ELEC_P: P2.6, R18.1, U6.6 (IO4)
/BrainBoard Analog In/CH5ELEC_P: P2.7, R17.1, U6.1 (IO1)
/BrainBoard Analog In/CH6ELEC_P: P2.8, R16.1, U6.3 (IO2)
/BrainBoard Analog In/CH7ELEC_P: P2.9, R15.1, U7.4 (IO3)
/BrainBoard Analog In/CH8ELEC_P: P2.10, R14.1, U7.6 (IO4)
/BrainBoard Analog In/REF_ELEC: P2.11, R13.1, U7.1 (IO1)
AGND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C55.2, C56.2, P2.14; also elsewhere on the board
AIN1N: C28.1, R22.2; also elsewhere on the board
AIN1P: C56.1, R23.2; also elsewhere on the board
AIN2N: C27.1, R20.2; also elsewhere on the board
AIN2P: C55.1, R21.2; also elsewhere on the board
AIN3P: C26.1, R19.2; also elsewhere on the board
AIN4P: C25.1, R18.2; also elsewhere on the board
AIN5P: C24.1, R17.2; also elsewhere on the board
AIN6P: C23.1, R16.2; also elsewhere on the board
AIN7P: C22.1, R15.2; also elsewhere on the board
AIN8P: C21.1, R14.2; also elsewhere on the board
BIAS: R12.2; also elsewhere on the board
REF: C20.1, R13.2; also elsewhere on the board
SHIELD: R11.2; also elsewhere on the board

Notes on the sheet:
Clamping diodes
Analog signal header
Channels 3-8 are single-ended only. Channels 1 and 2 can be configured as bipolar for auxilliary signals like EOG, EMG, ECG, etc.

Parts:
C29, C31, C33, C34, C35: 0.1uF
C30: 2.2uF
C32: 10uF
P3: CONN_5X2
U8: ATUC3L064

Connections:
+3.3V: C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, P3.4, U8.17 (VDDIN), U8.18 (VDDCORE), U8.34 (ADVREFP), U8.35 (VDDANA), U8.42 (VDDIO), U8.48 (VDDIO); also elsewhere on the board
/BrainBoard MCU/RESET_MCU: P3.6, U8.22 (RESET_N)
/BrainBoard MCU/TCK: P3.1, U8.11 (PA00)
/BrainBoard MCU/TDI: P3.9, U8.4 (PA03)
/BrainBoard MCU/TDO: P3.3, U8.13 (PA02)
/BrainBoard MCU/TMS: P3.5, U8.14 (PA01)
/CS_DAISY: U8.3 (PA08); also elsewhere on the board
/CS_MAIN: U8.6 (PB00); also elsewhere on the board
/DRDY: U8.41 (PA18); also elsewhere on the board
/PWDN: U8.2 (PA09); also elsewhere on the board
AGND: C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, P3.2, P3.10, U8.1 (GND), U8.19 (GND), U8.33 (GNDANA), U8.43 (GND), U8.45 (GND); also elsewhere on the board
DAISY_OUT: P3.8; also elsewhere on the board
I2C2_SCL: U8.28 (PA04); also elsewhere on the board
I2C2_SDA: U8.12 (PA05); also elsewhere on the board
IMU_INT: U8.46 (PA10); also elsewhere on the board
MISO: U8.7 (PB02); also elsewhere on the board
MOSI: U8.8 (PB03); also elsewhere on the board
RESET_BT: U8.44 (PB11); also elsewhere on the board
SCLK: U8.16 (PB01); also elsewhere on the board
UARTBT_CTS: U8.29 (PB09); also elsewhere on the board
UARTBT_RTS: U8.32 (PB08); also elsewhere on the board
UARTBT_RX: U8.31 (PB07); also elsewhere on the board
UARTBT_TX: U8.30 (PB06); also elsewhere on the board
UARTUC_RX: U8.15 (PA07); also elsewhere on the board
UARTUC_TX: U8.10 (PA06); also elsewhere on the board

Notes on the sheet:
JTAG INTERFACE / TOP NON-PASS-THROUGH CONNECTOR
MCU uses on-chip oscillator to save board space.
/DRDY on EXTINT[5]

Parts:
D1: STAT
D2: CONN
P4: BTRST
R24, R25: 330
R26: 10K
U9: BLUETOOTH-RN42

Connections:
+3.3V: U9.11 (VDD); also elsewhere on the board
/BrainBoard Bluetooth/FACTORY: P4.1, R26.1, U9.22 (PIO4)
/BrainBoard Bluetooth/STATUS: D2.1 (A), U9.19 (PIO2)
/BrainBoard Bluetooth/STATUSn: D1.1 (A), U9.21 (PIO5)
AGND: R24.2, R25.2, R26.2, U9.1 (GND), U9.12 (GND1), U9.25 (GND2), U9.27 (GND3), U9.28 (GND4), U9.29 (GND5); also elsewhere on the board
unnamed: D2.2 (K), R25.1
unnamed: D1.2 (K), R24.1
RESET_BT: U9.5 (RESET); also elsewhere on the board
UARTBT_CTS: U9.15 (UARTRTS); also elsewhere on the board
UARTBT_RTS: U9.16 (UARTCTS); also elsewhere on the board
UARTBT_RX: U9.14 (UARTTX); also elsewhere on the board
UARTBT_TX: U9.13 (UARTRX); also elsewhere on the board

Parts:
C36, C39, C43, C48: 10uF
C37, C38, C40, C41, C46, C58: 1uF
C42, C47, C57: 0.01uF
C44, C49: 2.2uF
C45: 0.1uF
P6: -3V3
P8: +2V5
P9: -2V5
P11: JST
P12: CONN_4
P13: VBAT
P14: ~ALRT
R10: 75k
R27: 180
R28: 1k
TH1: 10k NTC
U10: TPS60403
U11: TPS73225
U12: TPS72325
U14: MAX17043

Connections:
+2.5V: C43.1, C44.1, C45.1, P8.1, U11.5 (OUT); also elsewhere on the board
+3.3V: C36.1, C37.1, C41.1, U10.2 (IN), U11.1 (IN), U11.3 (EN); also elsewhere on the board
+BATT: P11.2 (PM), P12.1, P12.2, P13.1, R27.1, R28.1
-2.5V: C45.2, C48.1, C49.1, P9.1, U12.5 (OUT); also elsewhere on the board
-3.3V: C39.1, C40.1, C46.1, P6.1, U10.1 (OUT), U12.2 (IN), U12.3 (EN)
/BrainBoard Power/TS: P12.3, R10.1, TH1.1
/BrainBoard Power/~ALRT: P14.1, U14.5 (~ALRT)
AGND: C36.2, C37.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C46.2, C47.2, C48.2, C49.2, C57.2, C58.2, P11.1, P12.4, R10.2, TH1.2, U10.4 (GND), U11.2 (GND), U12.1 (GND), U14.1 (CTG), U14.4 (GND), U14.6 (QSTRT), U14.EP (GND); also elsewhere on the board
I2C2_SCL: U14.7 (SCL); also elsewhere on the board
I2C2_SDA: U14.8 (SDA); also elsewhere on the board
unnamed: C42.1, U11.4 (NR)
unnamed: C38.1, U10.5 (CFLY+)
unnamed: C38.2, U10.3 (CFLY-)
unnamed: C47.1, U12.4 (NR)
unnamed: C57.1, R27.2, U14.3 (VDD)
unnamed: C58.1, R28.2, U14.2 (CELL)

Notes on the sheet:
Fuel gauge and BBB battery connection
Connect SENSE to BAT directly at battery terminal

Parts:
C1, C6, C11, C12, C15, C16, C50: 0.1uF
C2: 1nF
C3: 10uF
C4, C5, C7, C9, C10, C13, C14: 1uF
C8: 100uF
P10: CONN_2X2
R7, R8: 10K
R9: 499K,0.1%
SJ1: REF-SRB2; SparkFun-Passives-SJ_3_PASTE2&3
SJ2, SJ7: DAISY_CS; SparkFun-Passives-SJ_3_PASTE2&3
SJ3: NO BIAS FILT; SparkFun-Passives-SJ_2S-NO
SJ6: DAISY_OUT; SparkFun-Passives-SJ_3_PASTE2&3
SJ8: CLKSEL; SparkFun-Passives-SJ_3_PASTE1&2
U3: OPA2376; MSOP8
U4: ADS1299; TQFP_64

Connections:
+2.5V: C1.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, U3.8 (+V), U4.19 (AVDD), U4.21 (AVDD), U4.22 (AVDD), U4.54 (AVDD1), U4.56 (AVDD), U4.59 (AVDD); also elsewhere on the board
+3.3V: C14.1, C16.1, R7.1, R8.1, SJ8.1, U4.36 (~RESET), U4.48 (DVDD), U4.50 (DVDD); also elsewhere on the board
-2.5V: C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C13.2, C15.2, C50.1, U3.4 (-V), U4.20 (AVSS), U4.23 (AVSS), U4.25 (VREFN), U4.32 (AVSS), U4.53 (AVSS1), U4.57 (AVSS), U4.58 (AVSS); also elsewhere on the board
/BrainBoard AFE//CS: R7.2, SJ2.2, U4.39 (~CS)
/BrainBoard AFE/BIASINV: C2.1, R9.2, SJ3.1, U4.61 (BIASINV)
/BrainBoard AFE/BIASOUT: C2.2, R9.1, SJ3.2, U4.63 (BIASOUT)
/BrainBoard AFE/CLKSEL: SJ8.2, U4.52 (CLKSEL)
/BrainBoard AFE/DAISY: SJ7.2, U4.41 (DAISY_IN)
/BrainBoard AFE/DAISY_IN: P10.1, SJ7.1
/BrainBoard AFE/DOUT: SJ6.2, U4.43 (DOUT)
/BrainBoard AFE/SRB1: U3.6 (-IN_B), U3.7 (OUT_B), U4.1 (IN8N), U4.3 (IN7N), U4.5 (IN6N), U4.7 (IN5N), U4.9 (IN4N), U4.11 (IN3N), U4.17 (SRB1)
/BrainBoard AFE/SRB2: SJ1.1, U4.18 (SRB2)
/BrainBoard AFE/VCAP1: C8.1, U4.28 (VCAP1)
/BrainBoard AFE/VCAP2: C7.1, U4.30 (VCAP2)
/BrainBoard AFE/VCAP3: C5.1, C6.1, U4.55 (VCAP3)
/BrainBoard AFE/VCAP4: C4.1, U4.26 (VCAP4)
/BrainBoard AFE/VREFP: C3.2, U4.24 (VREFP)
/CS_DAISY: SJ2.1; also elsewhere on the board
/CS_MAIN: SJ2.3; also elsewhere on the board
/DRDY: U4.47 (~DRDY); also elsewhere on the board
/PWDN: R8.2, U4.35 (~PWDN); also elsewhere on the board
AGND: C1.2, C10.2, C12.2, C14.2, C16.2, C50.2, SJ7.3, SJ8.3, U4.31 (RESV1), U4.33 (DGND), U4.38 (START), U4.42 (GPIO1), U4.44 (GPIO2), U4.45 (GPIO3), U4.46 (GPIO4), U4.49 (DGND), U4.51 (DGND); also elsewhere on the board
AIN1N: U4.15 (IN1N); also elsewhere on the board
AIN1P: U4.16 (IN1P); also elsewhere on the board
AIN2N: U4.13 (IN2N); also elsewhere on the board
AIN2P: U4.14 (IN2P); also elsewhere on the board
AIN3P: U4.12 (IN3P); also elsewhere on the board
AIN4P: U4.10 (IN4P); also elsewhere on the board
AIN5P: U4.8 (IN5P); also elsewhere on the board
AIN6P: U4.6 (IN6P); also elsewhere on the board
AIN7P: U4.4 (IN7P); also elsewhere on the board
AIN8P: U4.2 (IN8P); also elsewhere on the board
BIAS: U3.3 (+IN_A), U4.62 (BIASIN); also elsewhere on the board
CLK: U4.37 (CLK); also elsewhere on the board
DAISY_OUT: SJ6.1; also elsewhere on the board
MISO: SJ6.3; also elsewhere on the board
MOSI: U4.34 (DIN); also elsewhere on the board
unnamed: SJ1.2, U3.5 (+IN_B)
REF: SJ1.3; also elsewhere on the board
SCLK: U4.40 (SCLK); also elsewhere on the board
SHIELD: U3.1 (OUT_A), U3.2 (-IN_A); also elsewhere on the board

Notes on the sheet:
For daisy-chain operation, use the following jumper settings: SJ2, SJ6, SJ7, SJ8 @ 2-3 for master AFE (provides clock and bias supply); SJ2, SJ6, SJ7, SJ8 @ 1-2 for additional AFEs

Parts:
C51, C52: 0.1uF
C53: 2.2nF
C54: 0.01uF
SJ9: I2C Address Select (2&3NC); SparkFun-Passives-SJ_3_PASTE2&3
U13: MPU6050

Connections:
+3.3V: C51.1, C54.1, SJ9.1, U13.8 (VLOGIC), U13.13 (VDD); also elsewhere on the board
/BrainBoard IMU/AD0: SJ9.2, U13.9 (AD0)
/BrainBoard IMU/CPOUT: C53.1, U13.20 (CPOUT)
/BrainBoard IMU/REGOUT: C52.1, U13.10 (REGOUT)
AGND: C51.2, C52.2, C53.2, C54.2, SJ9.3, U13.1 (CLKIN), U13.11 (FSYNC), U13.18 (GND); also elsewhere on the board
I2C2_SCL: U13.23 (SCL); also elsewhere on the board
I2C2_SDA: U13.24 (SDA); also elsewhere on the board
IMU_INT: U13.12 (INT); also elsewhere on the board
