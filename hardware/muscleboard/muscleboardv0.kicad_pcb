# Repository gskelly/eeg (continued)

## KiCad design hardware/brainboard/brainboard_wearable_v2/brainboard_wearable_v2.kicad_pcb (continued)

Parts:
C50, C51, C52: 0.1uF
C53, C54, C55, C56, C57, C58, C59, C60, C61, C62, C63: 4.7nF
P10: CONN_14
R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 4.99K
U12, U13, U14: TPD4E001DBV

Connections:
+2.5V: C50.1, C51.1, C52.1, U12.5 (VCC), U13.5 (VCC), U14.5 (VCC); also elsewhere on the board
-2.5V: C50.2, C51.2, C52.2, U12.2 (GND), U13.2 (GND), U14.2 (GND); also elsewhere on the board
/Brainboard Analog In/BIAS_ELEC: P10.2, R21.1, U14.3 (IO2)
/Brainboard Analog In/CH1ELEC_N: P10.14, R31.1, U12.6 (IO4)
/Brainboard Analog In/CH1ELEC_P: P10.13, R32.1, U12.4 (IO3)
/Brainboard Analog In/CH2ELEC_N: P10.12, R29.1, U12.3 (IO2)
/Brainboard Analog In/CH2ELEC_P: P10.11, R30.1, U12.1 (IO1)
/Brainboard Analog In/CH3ELEC_P: P10.10, R28.1, U13.4 (IO3)
/Brainboard Analog In/CH4ELEC_P: P10.9, R27.1, U13.6 (IO4)
/Brainboard Analog In/CH5ELEC_P: P10.8, R26.1, U13.1 (IO1)
/Brainboard Analog In/CH6ELEC_P: P10.7, R25.1, U13.3 (IO2)
/Brainboard Analog In/CH7ELEC_P: P10.6, R24.1, U14.4 (IO3)
/Brainboard Analog In/CH8ELEC_P: P10.5, R23.1, U14.6 (IO4)
/Brainboard Analog In/REF_ELEC: P10.4, R22.1, U14.1 (IO1)
AGND: C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2; also elsewhere on the board
AIN1N: C62.1, R31.2; also elsewhere on the board
AIN1P: C63.1, R32.2; also elsewhere on the board
AIN2N: C60.1, R29.2; also elsewhere on the board
AIN2P: C61.1, R30.2; also elsewhere on the board
AIN3P: C59.1, R28.2; also elsewhere on the board
AIN4P: C58.1, R27.2; also elsewhere on the board
AIN5P: C57.1, R26.2; also elsewhere on the board
AIN6P: C56.1, R25.2; also elsewhere on the board
AIN7P: C55.1, R24.2; also elsewhere on the board
AIN8P: C54.1, R23.2; also elsewhere on the board
BIAS: R21.2; also elsewhere on the board
REF_IN: C53.1, R22.2; also elsewhere on the board
SHIELD: P10.1, P10.3; also elsewhere on the board

Notes on the sheet:
Clamping diodes
Analog signal header
Channels 3-8 are single-ended only. Channels 1 and 2 can be configured as bipolar for auxilliary signals like EOG, EMG, ECG, etc.

Board: 4 copper layers, 61.1 x 54.6 mm, 134 parts (0 on the bottom side), 89 nets.

File hardware/brainboard/brainboard_wearable_v2/brainboard_wearable_v2_BOM_REVISED.csv:

VALUE,COUNT,REF,,,,,,,
1nF,1,C7,~,Kemet,C0603C102K3RACTU,DigiKey,$0.10/1 $0.02/10 $0.0108/50,,
2.2nF,1,C3,~,,,,,,
4.7nF,11,C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 C63,~,Kemet,C0603C472K5RACTU,DigiKey,$0.10/1 $0.03/10 $0.0162/50,,
0.01uF,4,C4 C33 C34 C35,~,,,,,,
0.1uF,5,C1 C2 C24 C31 C42,~,,,,,,
0.1uF,15,C5 C6 C11 C15 C18 C19 C22 C23 C43 C45 C47 C48 C49 C50 C51,~,Kemet,C0603C104K4RACTU,DigiKey,$0.10/1 $0.022/10 $0.0118/50,,
0.1uF,1,C52,~,Kemet,C0603C104K4RACTU,DigiKey,$0.10/1, $0.022/10, $0.0118/50
1uF,8,C9 C10 C12 C14 C16 C17 C20 C21,~,Kemet,C0603C105K8PACTU,DigiKey,$0.10/1 $0.039/10 $0.021/50,,
1uF,4,C27 C28 C30 C32,~,,,,,,
2.2uF,4,C25 C39 C40 C41,~,,,,,,
2.2uF,1,C44,~,Kemet,C0603C225K8PACTU,DigiKey,$0.17/1 $0.113/10 $0.0676/50,,
10uF,2,C8 C46,~,Kemet,C0805C106Z8VACTU,DigiKey,$0.16/1 $0.111/10 $0.063/50,,
10uF,5,C26 C29 C36 C37 C38,~,,,,,,
100uF,1,C13,~,Vishay Sprague,TL8A0107M010C,DigiKey,$1.35/1 $1.128/10,,
USB,1,CON1,~,,,,,,
SMAJ7.0A,1,D1,~,,,,,,
BATTLO,1,D2,~,,,,,,
PGOOD,1,D3,~,,,,,,
CHARGE,1,D4,~,,,,,,
STAT,1,D5,~,Kingbright Company LLC,APT1608SRCPRV,DigiKey,$0.17/1 $0.131/10 $0.1044/25,,
CONN,1,D6,~,Kingbright Company LLC,APT1608SGC,DigiKey,$0.16/1 $0.117/10 $0.0936/25,,
PTC 500mA,1,F1,~,,,,,,
MHOLE,3,MTG1 MTG2 MTG3,~,,,,,,
JST,1,P1,~,,,,,,
CONN_5X2,1,P8,~,FCI,95278-101B10LF,Mouser,$0.86/1 $0.737/10 $0.673/100,,
CONN_14,1,P10,~,,,,,,
1.18k,1,R13,~,,,,,,
2.2k,4,R11 R14 R15 R16,~,,,,,,
2.2k,2,R17 R18,~,Stackpole Electronics,RMCF0603JT330R,DigiKey,$0.02/1 $0.017/10 $0.0092/50,,
4.7k,2,R4 R5,~,,,,,,
4.99K,12,R21 R22 R23 R24 R25 R26 R27 R28 R29 R30 R31 R32,~,Stackpole Electronics,RNCS0603BKE4K99,DigiKey,$0.70/1 $0.475/10 $0.2876/50,,
10K,2,R1 R2,~,Stackpole Electronics,RMCF0603JT10K0,DigiKey,$0.02/1 $0.017/10 $0.0092/50,,
10k,4,R6 R7 R19 R20,~,,,,,,
51.1k,1,R9,~,,,,,,
52.3k,1,R12,~,,,,,,
383k,1,R10,~,,,,,,
499K 0.10%,1,R3,~,Stackpole Electronics,RNCS0805BKE499K,DigiKey,$0.77/1, $0.523/10, $0.3162/50
562k,1,R8,~,,,,,,
DPDT,1,S1,~,,,,,,
NO BIAS FILT,1,SJ1,SparkFun-Passives-SJ_2S-NO,,,,,,
NTC 10K,1,TH1,~,,,,,,
GND,2,TP1 TP2,~,,,,,,
PREREG,1,TP3,~,,,,,,
-3V3,1,TP4,~,,,,,,
+2V5,1,TP5,~,,,,,,
-2V5,1,TP6,~,,,,,,
BTRST,1,TP7,~,,,,,,
3V3,1,TP8,~,,,,,,
MPU6050,1,U1,,,,,,,
LTC1998,1,U4,,,,,,,
BQ24074(T),1,U5,,,,,,,
ATUC3L064,1,U10,,Atmel,AT32UC3L064-AUT,DigiKey,$7.80/1 $4.898/25,,
BLUETOOTH-RN42,1,U11,,Microchip Technology,RN42-I/RM,DigiKey,$19.14/1 $15.95/10,,
OPA2376,1,U2,MSOP8,Texas Instruments,OPA2376AIDGKR,DigiKey,$2.73/1 $2.462/10 $2.206/25,,
ADS1299,1,U3,TQFP_64,Texas Instruments,ADS1299IPAG,DigiKey,$58.14/1,,
TPS60403,1,U6,~,,,,,,
TPS73233,1,U7,~,,,,,,
TPS73225,1,U8,~,,,,,,
TPS72325,1,U9,~,,,,,,
TPD4E001DBV,3,U12 U13 U14,~,,,,,,

## KiCad design hardware/brainboard/brainboard_wearable_v1/brainboard_wearable.kicad_pcb

Parts:
BT1: LIR2450
C1, C2, C9, C11, C14: 0.1uF
C3, C6, C15: 10uF
C4, C5: 30pF
C8, C10, C16, C17: 1uF
C12, C13: 4.7nF
C18: 1.5nF
FB1: BLM18PG121SN1
P1: CONN_3X2
P2: ICSP
R1: 10k
R2: 51k
R3: 1M
S1: DPDT
TP1: FACT
TP2: STATUS
U1: ATMEGA328P-28PIN
U2: ADS1291/2
U3: BLUETOOTH-RN42
Y1: ABM3B-8.000MHZ

Connections:
+BATT: BT1.1 (+), C3.1, C6.1, S1.1, S1.4
/AREF: C1.1, U1.17
/BT_CONN: U1.21, U3.19 (PIO2)
/BT_RESET: U1.20, U3.5 (RESET)
/FACTORY_RESET: TP1.1, U1.19, U3.22 (PIO4)
/MCU_RX: U1.26, U3.14 (UARTTX)
/MCU_TX: U1.27, U3.13 (UARTRX)
/PGA1N: C12.2, U2.1 (PGA1N)
/PGA1P: C12.1, U2.2 (PGA1P)
/PGA2N: C13.2, U2.7 (PGA2N)
/PGA2P: C13.1, U2.8 (PGA2P)
/RLDIN: C18.1, R2.1, R3.1, U2.29 (RLDIN/RLDREF), U2.30 (RLDOUT)
/RLDINV: C18.2, R3.2, U2.28 (RLDINV)
/STATUS: TP2.1, U3.21 (PIO5)
/VCAP1: C17.1, U2.11 (VCAP1)
/VCAP2: C16.1, U2.27 (VCAP2)
/VREFP: C14.1, C15.1, U2.9 (VREFP)
/~MCU_CTS: U1.1, U3.15 (UARTRTS)
/~MCU_RTS: U1.2, U3.16 (UARTCTS)
AVDD: C8.1, C9.1, FB1.2, U2.12 (AVDD), U2.31 (RESP_MODP), U2.32 (RESP_MODN)
CH1N: P1.3, U2.3 (IN1N)
CH1P: P1.4, U2.4 (IN1P)
CH2N: P1.5, U2.5 (IN2N)
CH2P: P1.6, U2.6 (IN2P)
DVDD: C2.1, C10.1, C11.1, FB1.1, R1.1, U1.3, U1.16, U2.23 (DVDD), U3.11 (VDD); also elsewhere on the board
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.2, C17.2, P2.6, U1.4, U1.18, U1.29, U2.10 (VREFN), U2.13 (AVSS), U2.24 (DGND), U2.33 (PAD), U3.1 (GND), U3.12 (GND), U3.28 (GND), U3.29 (GND); also elsewhere on the board
MISO: P2.1, U1.14, U2.21 (DOUT)
MOSI: P2.4, U1.13, U2.19 (DIN)
unnamed: C5.2, U1.6, Y1.2
unnamed: C4.2, U1.5, Y1.1
RLD: P1.2, R2.2
SCLK: P2.3, U1.15, U2.20 (SCLK)
VCC: S1.2, S1.5; also elsewhere on the board
VEXT: P2.2, S1.3, S1.6
~AFE_CS: U1.11, U2.18 (~CS)
~AFE_DRDY: U1.28, U2.22 (~DRDY)
~AFE_PWDN: U1.7, U2.15 (~PWDN~/~RESET)
~MCU_RESET: P2.5, R1.2, U1.25

Notes on the sheet:
ISP Programming - NI
Power
VCAP1 should connect to Class 1 ceramic or tantalum capacitor to avoid ferroelectric noise.
Electrode connector
Front-end
Supply filtering
Microcontroller
Bluetooth

Board: 2 copper layers, 30 parts (0 on the bottom side), 33 nets.

Other parts of the board:
U4: TPS73233; sot23-5

Their connections:
DVDD: U4.5; also elsewhere on the board
GND: U4.2; also elsewhere on the board
VCC: U4.1, U4.3; also elsewhere on the board

## KiCad design hardware/brainboard/brainboard_batteryv0/brainboard_batteryv0.kicad_pcb

Parts:
C1, C11: 0.1uF
C2, C3, C4, C5, C7: 10uF
C6, C8: 0.01uF
C9: 0.47uF
C10: 2.2uF
CON1: USB-MINI-B
D1: SMAJ7.0A
D2: PGOOD
D3: CHARGE
D4: PMEG2005AEA
D5: POWER
F1, F2: PTC 1.95A
P1: JST
P2: VBAT
P3: GND
P4: BBB_PMIC
P5: ~ALRT
P6: VBUS
P7: WP
P8: EN
P9: PREREG
P10: 3V3
Q1: SI2312
R1: 75k
R2, R3, R4: 4.7k
R5, R17: 806k
R6: 191k
R7: 1.18k
R8, R10, R11, R18: 2.2k
R9: 10k
R12, R13: 5.6k
R14: 30.1k
R15, R16: 52.3k
S1: SYSOFF
S2: BBB_SLEEP
SJ1, SJ2: BAT; SparkFun-Passives-SJ_2S-NO
SJ3: TS PMIC; SparkFun-Passives-SJ_2S
SJ4: A2-0; SparkFun-Passives-SJ_2S-NO
SJ5: A1-0; SparkFun-Passives-SJ_2S-NO
SJ6: LOWBAT_DIS; SparkFun-Passives-SJ_3_PASTE1&2
SJ7: SENSE; SparkFun-Passives-SJ_2S-NO
TH1: NTC 10K
U1: MAX17048
U2: BQ24074(T)
U3: 24C256
U4: TPS73601-SON
U5: LTC2951-1
U6: BEAGLEBONE_BLACK

Connections:
+3.3V: D4.2 (K), P10.1, R2.1, R3.1, R4.1, R9.1, R12.1, R13.1, R18.2, U3.8 (VCC), U6.A3 (VDD_3V3B), U6.A4 (VDD_3V3B), U6.B3 (VDD_3V3B), U6.B4 (VDD_3V3B)
+BATT: C1.1, C2.1, C3.1, F1.1, P2.1, Q1.1 (G), R5.1, R17.1, SJ1.1, SJ2.1, SJ6.3, SJ7.1, U1.2 (CELL), U1.3 (VDD), U2.2 (BAT), U2.3 (BAT), U5.4 (VIN)
/A0: R4.2, U3.1 (A0)
/A1: R3.2, SJ5.2, U3.2 (A1)
/A2: R2.2, SJ4.2, U3.3 (A2)
/B+: F1.2, P1.2 (PM)
/B-: P1.1, Q1.3 (D)
/BAT: P4.1, SJ1.2, SJ2.2
/BBB_TS: P4.2, R1.1, SJ3.1
/EN: P8.1, R17.2, U4.5, U5.7 (EN)
/FB: C8.2, R14.2, R15.2, U4.3
/ILIM: R7.2, U2.12 (ILIM)
/ISET: R8.1, U2.16 (ISET)
/LOWBAT: C6.1, R5.2, R6.1, SJ6.1
/OFFT: C9.1, U5.6 (OFFT)
/OUT: C7.1, C11.1, P9.1, R10.1, R11.1, U2.5 (EN2), U2.10 (OUT), U2.11 (OUT), U4.8
/PWR_BUT: S2.2, S2.4, U6.B9 (PWR_BUT)
/REGOUT: C8.1, C10.1, D4.1 (A), R15.1, U4.1
/SCL: R13.2, U1.7 (SCL), U3.6 (SCL), U6.B19 (I2C2_SCL)
/SDA: R12.2, U1.8 (SDA), U3.5 (SDA), U6.B20 (I2C2_SDA)
/SENSE: P4.3, SJ7.2
/TMR: R16.1, U2.14 (TMR)
/TS: SJ3.2, TH1.1, U2.1 (TS)
/VBUS: C4.1, C5.1, D1.2 (K), F2.1, P6.1, U2.13 (IN)
/VIN: CON1.1 (VBUS), F2.2
/WP: P7.1, R9.2, U3.7 (WP)
/~ALRT: P5.1, U1.5 (~ALRT)
/~CHG: D3.2 (K), U2.9 (~CHG)
/~KILL: SJ6.2, U5.5 (~KILL), U5.8 (~INT)
/~PB: S1.2, S1.4, U5.3 (~PB)
/~PGOOD: D2.2 (K), U2.7 (~PGOOD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), D1.1 (A), D5.2 (K), P3.1, P4.4, Q1.2 (S), R1.2, R6.2, R7.1, R8.2, R14.1, R16.2, S1.1, S1.3, S2.1, S2.3, SJ4.1, SJ5.1, TH1.2, U1.1 (CTG), U1.4 (GND), U1.6 (QSTRT), U1.9 (GND), U2.4 (~CE), U2.6 (EN1), U2.8 (VSS), U2.15 (TD/ITERM/SYSOFF), U2.17 (PWPD), U3.4 (GND), U4.4, U4.9, U5.1 (GND), U5.9 (GND), U6.A1 (DGND), U6.A2 (DGND), U6.B1 (DGND), U6.B2 (DGND), U6.B43 (DGND), U6.B44 (DGND), U6.B45 (DGND), U6.B46 (DGND)
unnamed: D3.1 (A), R10.2
unnamed: D2.1 (A), R11.2
unnamed: D5.1 (A), R18.1

Notes on the sheet:
Fuel/gas gauge
Battery charger
3.3V regulation
BeagleBone Black battery connector included for experimentation; DO NOT COMBINE with on-board charger and LDO
EEPROM for cape config
Connect SENSE to BAT directly at battery terminal
TO DO: - Connection to ~ALRT~ on P8
Fast charging current = K_ISET/R_ISET K_ISET = [797..975], 890 typical R_ISET = 2.2k yields about 400mA, or 0.2C for 2000mAh cell Input current limit = K_ILIM/R_ILIM See datasheet for K_ILIM ranges R_ILIM = 1.18k yields 1.3A
Power-off logic
Undervoltage detection: ~KILL~ < 0.6V if VBATT < 3.1V, turning off regulator
Brief SYSOFF press latches EN hi-Z ("on"). Long (3 sec) press latches EN low ("off").
C_OFFT = (1.56e-4 uF/ms)*(t_offt - 33 ms) C_OFFT = 0.47 uF --> t_offt = 3.045 s
REGOUT = 1.204*(R17+R18)/R18
Reverse polarity protection
TPS73601 can supply up to 400mA w/ VDO = 70 mV @ 25 deg C
The 3.3V rail generated on-board is used when operating independently of the BeagleBone Black. D4 prevents reverse current in the event the BBB is accidentally used for power. REGOUT can be adjusted to compensate for voltage drop across D4, or D4 can be DNP and shorted.
DNP
T_MAXCHG = 10*K_TMR*R_TMR K_TMR = 48s/kOhm R_TMR = 52.3k gives about 7 hr safety cutoff
USB on bottom layer. DNP if using BBB's charging circuitry via 4-hole battery header.

Board: 2 copper layers, 86.4 x 54.6 mm, 64 parts (39 on the bottom side), 35 nets.
