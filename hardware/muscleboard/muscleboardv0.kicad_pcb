# Repository gskelly/eeg (continued)

## KiCad design hardware/brainboard/brainboardv1/brainboardv1.kicad_pcb (continued)

Board: 4 copper layers, 86.4 x 54.6 mm, 127 parts (0 on the bottom side), 92 nets.

File hardware/brainboard/brainboardv0/brainboardv0_parts.xlsx:

Ref | Value | Manufacturer | PN | Vendor
C1 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C2 | 1nF | Kemet | C0603C102K3RACTU | DigiKey
C3 | 10uF | Kemet | C0805C106Z8VACTU | DigiKey
C4 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C5 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C6 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C7 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C8 | 100uF | Vishay Sprague | TL8A0107M010C | DigiKey
C9 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C10 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C11 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C12 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C13 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C14 | 1uF | Kemet | C0603C105K8PACTU | DigiKey
C15 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C16 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C17 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C18 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C19 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C20 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C21 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C22 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C23 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C24 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C25 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C26 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C27 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C28 | 4.7nF | Kemet | C0603C472K5RACTU | DigiKey
C29 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C30 | 2.2uF | Kemet | C0603C225K8PACTU | DigiKey
C31 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C32 | 10uF | Kemet | C0805C106Z8VACTU | DigiKey
C33 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C34 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C35 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
C36 | 0.1uF | Kemet | C0603C104K4RACTU | DigiKey
D1 | RED | Kingbright Company LLC | APT1608SRCPRV | DigiKey
D2 | GREEN | Kingbright Company LLC | APT1608SGC | DigiKey
P2 | CONN_12 | Sullins Connector Solutions | PPPC121LGBN-RC | DigiKey
P3 | CONN_5X2 | FCI | 68602-110HLF | DigiKey
P8 | CONN_23X2 | Adafruit Industries | 706 | -
P9 | CONN_23X2 | Adafruit Industries | 706 | -
R1 | 4.7K | Stackpole Electronics | RMCF0603JT4K70 | DigiKey
R2 | 4.7K | Stackpole Electronics | RMCF0603JT4K70 | DigiKey
R3 | 4.7K | Stackpole Electronics | RMCF0603JT4K70 | DigiKey
R4 | 10K | Stackpole Electronics | RMCF0603JT10K0 | DigiKey
R5 | 5.6K | Stackpole Electronics | RMCF0603JT5K60 | DigiKey
R6 | 5.6K | Stackpole Electronics | RMCF0603JT5K60 | DigiKey
R7 | 10K | Stackpole Electronics | RMCF0603JT10K0 | DigiKey
R8 | 10K | Stackpole Electronics | RMCF0603JT10K0 | DigiKey
R9 | 499K, 0.10% | Stackpole Electronics | RNCS0805BKE499K | DigiKey
R10 | 10K | Stackpole Electronics | RMCF0603JT10K0 | DigiKey
R11 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R12 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R13 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R14 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R15 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R16 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R17 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R18 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R19 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R20 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R21 | 4.99K | Stackpole Electronics | RNCS0603BKE4K99 | DigiKey
R22 | 330 | Stackpole Electronics | RMCF0603JT330R | DigiKey
R23 | 330 | Stackpole Electronics | RMCF0603JT330R | DigiKey
R24 | 10K | Stackpole Electronics | RMCF0603JT10K0 | DigiKey
S2 | SMT_BUTTON | C&K Components | KMR231GLFS | DigiKey
U1 | 24C256 | Fremont Micro Devices USA | FT24C256A-UMR-B | DigiKey
U3 | OPA2376 | Texas Instruments | OPA2376AIDGKR | DigiKey
U4 | ADS1299 | Texas Instruments | ADS1299IPAG | DigiKey
U5 | TPD4E001 | Texas Instruments | TPD4E001DBVR | Mouser
U6 | TPD4E001 | Texas Instruments | TPD4E001DBVR | Mouser
U7 | TPD4E001 | Texas Instruments | TPD4E001DBVR | Mouser
U8 | ATUC3L064 | Atmel | AT32UC3L064-AUT | DigiKey
U9 | BLUETOOTH-RN42 | Microchip Technology | RN42-I/RM | DigiKey
U10 | TPS73150 | Texas Instruments | TPS73150DBVT | DigiKey

## Code that names these connections

File firmware/at32uc3l064/brainboard_fw/brainboard_fw/src/main.c (part):

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	 */
	gpio_enable_gpio_pin(AVR32_PIN_PB05);												// Default TWIMS0 TWCK
	gpio_enable_gpio_pin(AVR32_PIN_PA21);												// Default TWIMS0 TWD
	gpio_enable_module_pin(AVR32_TWIMS0_TWCK_0_0_PIN, AVR32_TWIMS0_TWCK_0_0_FUNCTION);	// PA04
	gpio_enable_module_pin(AVR32_TWIMS0_TWD_0_2_PIN, AVR32_TWIMS0_TWD_0_2_FUNCTION);	// PA05
	
	/* MPU6050 interrupt pin: polled at each ADS1299 DRDY */
	gpio_enable_gpio_pin(MPU6050_INT_PIN);												// PA10
	gpio_configure_pin(MPU6050_INT_PIN, GPIO_DIR_INPUT);
	#endif
	
	/* Config GPIOs for USART2 (wired data) */
	gpio_enable_module_pin(AVR32_USART2_TXD_0_1_PIN, AVR32_USART2_TXD_0_1_FUNCTION);	// PA06
	gpio_enable_pin_pull_up(AVR32_USART2_TXD_0_1_PIN);
	gpio_enable_module_pin(AVR32_USART2_RXD_0_1_PIN, AVR32_USART2_RXD_0_1_FUNCTION);	// PA07

	/* Config GPIOs for USART3 (RN-42 Bluetooth data) */
	gpio_enable_module_pin(AVR32_USART3_TXD_0_1_PIN, AVR32_USART3_TXD_0_1_FUNCTION);	// PB06
	gpio_enable_pin_pull_up(AVR32_USART3_TXD_0_1_PIN);
	gpio_enable_module_pin(AVR32_USART3_RXD_0_1_PIN, AVR32_USART3_RXD_0_1_FUNCTION);	// PB07
	gpio_enable_module_pin(AVR32_USART3_RTS_0_1_PIN, AVR32_USART3_RTS_0_1_FUNCTION);	// PB08
	gpio_enable_module_pin(AVR32_USART3_CTS_0_1_PIN, AVR32_USART3_CTS_0_1_FUNCTION);	// PB09
	
	/* Config GPIOs for SPI */
	gpio_enable_module_pin(AVR32_SPI_MISO_0_1_PIN, AVR32_SPI_MISO_0_1_FUNCTION);		// PB02
	gpio_enable_module_pin(AVR32_SPI_MOSI_0_1_PIN, AVR32_SPI_MOSI_0_1_FUNCTION);		// PB03
	gpio_enable_module_pin(AVR32_SPI_SCK_0_1_PIN, AVR32_SPI_SCK_0_1_FUNCTION);			// PB01
	gpio_enable_module_pin(AVR32_SPI_NPCS_0_1_PIN, AVR32_SPI_NPCS_0_1_FUNCTION);		// PB00
	
	/* RN-42 hardware reset pin */
	gpio_enable_gpio_pin(BT_RESET_PIN);													// PB11
	gpio_configure_pin(BT_RESET_PIN, GPIO_DIR_OUTPUT);
	
	/* ADS1299 control pins */
	#if (BRAINBOARD_REV == 0)
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	gpio_enable_gpio_pin(ADS1299_PIN_RESET);											// PB04
	gpio_configure_pin(ADS1299_PIN_RESET, GPIO_DIR_OUTPUT);
	#endif
	gpio_enable_gpio_pin(ADS1299_PIN_PWDN);												// PA09
	gpio_configure_pin(ADS1299_PIN_PWDN, GPIO_DIR_OUTPUT);
	/* ADS1299 DRDY interrupt pin */	
	gpio_enable_module_pin(ADS1299_PIN_DRDY, ADS1299_DRDY_INT_FN);						// PA18
}

status_code_t config_twim(void)
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{
	
	/* Reset-cycle RN-42 Bluetooth module */
	gpio_clr_gpio_pin(BT_RESET_PIN);
	delay_us(100);
	gpio_set_gpio_pin(BT_RESET_PIN);
	delay_ms(100);
	
	/* Configure RN-42 */
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	 * e.g. to set GPIO5 (bit 5 of MASK) as an output, write 0b0010000000100000 = 0x2020
	 *      to set it as an input,                     write 0b0010000000000000 = 0x2000
	 *
	 * Sending 0x1000 sets ALL GPIOs to inputs (since GPIO4 is used for factory reset and
	 * isn't user-controllable).
	 * 
	 * Here the STATUS and CONN LEDs are connected to GPIO5 and GPIO2, respectively.
	 * We may want to disable them to conserve power.
	 *
	 * Quick reference: 0x2424 sets GPIO5 and GPIO2 to outputs. 0x2400 sets them to inputs.
	 *
	 * NOTE: the S% command is stored on the flash, and GPIOs retain these settings on
	 * power cycle or reset. To make the change temporary, use S@ with the same argument.
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
File SPI Communication Test/src/ads1299.h (part):

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#define ADS1299_PIN_RESET		AVR32_PIN_PB04

/**
 *  \brief Defines the host processor pin assigned to the DRDY pin on the ADS1299.
 */
#define ADS1299_PIN_DRDY		AVR32_PIN_PB07
#define ADS1299_DRDY_INT		AVR32_EIC_INT1
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#define ADS1299_PIN_START		AVR32_PIN_PA17

/**
 *  \brief Defines the host processor pin assigned to the PWDN pin on the ADS1299.
 */
//#define ADS1299_PIN_PWDN		

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#define ADS1299_REGDEFAULT_ID			ADS1299_DEVICE_ID
#define ADS1299_REGDEFAULT_CONFIG1		0x96			///< Multiple readback mode, OSC output disabled, DR = FMOD/4096
#define ADS1299_REGDEFAULT_CONFIG2		0xD0			///< Test signal sourced internally, low-amplitude test signal pulsed at FCLK/(2^21)
#define ADS1299_REGDEFAULT_CONFIG3		0x68			///< Ref buffer off, bias measurement off, internal bias ref, bias buffer off, bias sense disabled
#define ADS1299_REGDEFAULT_LOFF			0x00			///< 95%/5% LOFF comparator threshold, DC lead-off at 6 nA	
#define ADS1299_REGDEFAULT_CHNSET		0xE0			///< Channel off, gain 24, SRB2 disconnected, normal electrode input
#define ADS1299_REGDEFAULT_BIAS_SENSP	0x00			///< All BIAS channels disconnected from positive leads
#define ADS1299_REGDEFAULT_BIAS_SENSN	0x00			///< All BIAS channels disconnected from negative leads
#define ADS1299_REGDEFAULT_LOFF_SENSP	0x00			///< All LOFF channels disconnected from positive leads
#define ADS1299_REGDEFAULT_LOFF_SENSN	0x00			///< All LOFF channels disconnected from negative leads
#define ADS1299_REGDEFAULT_LOFF_FLIP	0x00			///< No flipping in this house; source/pull-up at INP, sink/pull-down at INN
#define ADS1299_REGDEFAULT_LOFF_STATP	0x00			///< This is a read-only register; reset value is 0x00
#define ADS1299_REGDEFAULT_LOFF_STATN	0x00			///< This is a read-only register; reset value is 0x00
#define ADS1299_REGDEFAULT_GPIO			0x0F			///< All GPIO set to inputs
#define ADS1299_REGDEFAULT_MISC1		0x00			///< SRB1 disconnected
#define ADS1299_REGDEFAULT_MISC2		0x00			///< Register not used in this silicon; should stay at 0x00
#define ADS1299_REGDEFAULT_CONFIG4		0x00			///< Continuous conversion, LOFF comparator powered down

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 */
typedef enum
{
	CAL_AMP_VREF_DIV_2_4_MV		= 0,		///< Calibration signal amplitude is 1 x (VREFP - VREFN)/(2.4 mV).
	CAL_AMP_2VREF_DIV_2_4_MV	= 1			///< Calibration signal amplitude is 2 x (VREFP - VREFN)/(2.4 mV).
} ads1299_bitval_cal_amp_t;

/**
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
typedef enum
{
	SRB1_OFF					= 0,			///< Stim/ref/bias 1 turned off.
	SRB1_ON						= 1				///< Stim/ref/bias 1 connected to all channel inverting inputs.
} ads1299_bitval_srb1_t;

/**
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 *	\brief Enable continuous data output.
 *
 * This function sends the RDATAC opcode, which makes conversion data immediately available
 * to the host as soon as the DRDY pin goes low. The host need only send SCLKs to retrieve
 * the data, rather than starting with a RDATA command. Registers cannot be read or written
 * (RREG or WREG) in this mode. Cancel continuous read mode using ads1299_stop_rdatac().
 *
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
## Commit log

2013-06-27 Testing commit with existing AS6.1 project
2013-06-27 Initial test commit
2013-07-24 Reorg w/ subdirectories for FW and HW
2013-07-24 Deleted blank README
2013-07-26 BrainBoardGUI/spi/setup
2013-10-30 Added BB Rev 1 files
    Changelog: added missing traces on LEDs
    TODO: fix passives silkscreens too small or on top of pads, mark LED and
    tantalum polarities, enlarge P8 and P9 drills, mark TP vias on back
    silk, fix silk orientation consistency, break out SPI bus, try to place
    ADS1299 caps a bit closer to IC
2013-12-27 Nearly finished v1 sch & brd, await final check
    Fixed errors from Rev 0, added MPU-6050 accelerometer/gyro for head
    motion tracking, switched to +/-2.5V analog supply, added 2 bipolar
    analog inputs for EOG tracking, added daisy-chain capability
2013-12-30 Added thicker power traces and fixed silkscreen
2014-01-02 Added bottom layer ground plane
2014-01-02 Added cad for bottom layer ground plane
2014-01-02 Removed extra ground plane connection
    May not affect anything, especially on battery power, but trying to keep
    good layout practice
2014-01-03 Making dedicated battery board for now (rev0)
    Designed for Li-polymer batteries. Includes USB battery charging IC
    (MCP73831), footprints for 2 fuel gauges (pick one of MAX17043 or
    bq27510, because the former has an Arduino library but is impossible to
    source alone in small quantities), NTC thermistor, and 3.3V LDO.
2014-01-03 Reorganized sch a bit
2014-01-09 More battery changes
    Added power-down logic to battery board (currently faulty, need
    revision); added fuel gauge, 2-pin JST, and BBB battery connector to
    Brainboard R1.
    TODO: Fix power-down logic (suggest dedicated power-button supervisor
    like STM660x), add isolation so board can be safely plugged in to charge
2014-01-14 Just gonna use separate button for SYSOFF
2014-01-29 Semi-finished battery board rev0
    Everything laid out and routed, still need to check alignment of BBB
    battery connector holes
2014-01-30 Finalized hole positions, gerbers/drills
2014-03-19 Organized, added wearable folder
2014-09-09 Thesis version
    Finally able to commit again (Windows XP issues fixed by OS upgrade).
    Added latest version of wearable BB, along with prototype "muscleboard"
    2-channel board for EMG/ECG applications
2014-09-09 Firmware update
    Renamed solution and improved code readability a bit
2014-09-09 Thesis version redux
    Apparently some files didn't properly sync
2014-09-17 Added MATLAB/BCI2VR support
2014-09-17 Added thesis itself and updated readme
2014-09-17 Fixed readme formatting
2014-09-17 More readme updates
    Added contact info
2014-10-15 BOM update
2014-10-22 Fixed CLKSEL and START no-connects on muscleboard
    Also removed extraneous components including battery voltage
    divider--going to use ATMEGA328p's internal voltage reference to measure
    AVCC instead. AVCC is now directly tied to VCC
2014-11-11 Fixed a couple firmware bugs
    Clock was not properly initializing to RCSYS-derived DFLL with Atmel
    Studio 6.2; ADS1299 wasn't properly initialized before checking SPI
    comms integrity, leading to a hang
2015-06-02 Fixing R1 BOM - still missing a few PNs/manufacturers
    Got rid of misnamed CSV files, removed non-physical "components" from
    ODT BOM
    TODO: Ensure all PNs/manufacturers are filled in, double-check for all
    BOMs
2015-06-02 Fixed wearable_v2 BOM CSV
    May yet update all BOMs to a nicer spreadsheet format...
2015-06-12 Added missing PNs to BBv1 BOM
2015-09-16 Regenerate R1 BOM
2015-09-16 Regenerated wearable_v2 BOM
