# Repository gskelly/eeg

File README.md:

eeg
===

Software, firmware, and CAD files for Brainboard, a mobile EEG project.
Brainboard interfaces with a custom MATLAB program, BCI2VR
(http://www.engineering.vcu.edu/eegbci/bci2vr_index.html), via Bluetooth.
The core hardware components are the ADS1299 EEG front-end from Texas
Instruments, the AT32UC3L064 microcontroller from Atmel, the MPU-6050 
6-axis inertial measurement unit from InvenSense, and the RN-42 Bluetooth
2.1 module from Microchip/Roving Networks.

Current firmware is for the Atmel AT32UC3L064, a 32-bit AVR microcontroller.
Some experimentation was done with on-line digital processing of the acquired
EEG signals from within the AVR firmware, but this is currently incomplete.
The microcontroller acts as a dumb pipe shuttling 8 channels of 24-bit data
from the ADS1299 and 6 channels of 16-bit data from the MPU-6050, where they
are displayed using the BCI2VR MATLAB GUI. Firmware is flashed to the MCU using
a 10-pin JTAG connection and the AVR Dragon (or other AVR32-compatible
programmer). Code was developed using the free Atmel Studio IDE.

The project predates my use of a proper versioning system, and thus
the hardware folder contains designs (some old, some WIP) for the Brainboard. 
***The most recent complete version is brainboard_wearable_v2.***
Older versions may be viewed for completeness's sake and/or compared with the
thesis document for a full picture of the design process.
The folders "muscleboard" and "brainboard_v2" are works in progress. The former
is meant for single-channel EMG acquisition and acceleration measurements in a
small, 3-electrode form factor that can be mounted on a disposable electrode pad.
This will probably ultimately be moved to its own repository. Brainboard v2 is a
BeagleBone Black cape that takes the BBB support from earlier versions of the
Brainboard and re-implements it in a more elegant fashion (see thesis for details).

**To use the BCI2VR GUI (assumes you already have MATLAB r2011b or later):**

1. Go to the link above and download the required MATLAB files for the basic BCI2VR functionality.

2. Copy btv_brainBoardBtFun.m into the functions folder.

3. Copy brainBoardBt_btv_daq_settings.m and brainBoardBt_14Ch.loc into the setup_files folder.

4. Make sure the toolbox is added to your path. Run bci2vr.m and click "Data Acquisition." 

5. Click the "Load setup file" icon and load brainBoardBt_btv_daq_settings.

6. The program will attempt to open a Bluetooth connection with BrainBoard. It occasionally fails; in this case simply close the GUI and try again.

7. Click the "Play" icon to begin recording.

For more info, check Dr. Ou Bai's documentation for BCI2VR, included with the toolbox.

Questions may be directed toward Graham Kelly, preferably at kellygs@vcu.edu, or at graham.smith.kelly@gmail.com as a backup. Dr. Bai may be reached at obai@vcu.edu.

## KiCad design hardware/muscleboard/muscleboardv0.kicad_pcb

Board: 4 copper layers, 33.2 x 36.6 mm, 54 parts (0 on the bottom side), 47 nets.

Parts:
C1, C2, C3, C5, C9, C15, C20, C21, C23, C25: 0.1uF; c_0402
C4, C8: 4.7uF; c_0805
C10: 0.01uF; c_0402
C11, C16: 10uF; c_0603
C12: 2.2uF; c_0402
C13, C14: 4.7nF; c_0402
C17, C18, C22, C24: 1uF; c_0402
C19: 1.5nF; c_0402
D1: CHG; Led_0603
D2: LSM115JE3/TR13; do214aa
D3: RED; Led_0603
FB1: BLM18PG121SN1; inductor_smd_0603
L1: 10uH; inductor_smd_0603
MTG1: MHOLE; BBB_MHOLE
P1: BATT; s2b-ph-sm4-tb
P2: USB; USB_MINI_B
P3: ICSP; pin_strip_3x2
P4: ELEC; bb02-hy03a
R1: 2.2M; r_0402
R2, R12: 1M; r_0402
R3, R5, R9, R10: 10k; r_0402
R4, R7: 2.2k; r_0402
R8: 51k; r_0402
S2: CHG/ON; JS102011SAQN
TP1: GND; testpoint_1mm5
TP2: 3V3; testpoint_1mm5
TP3: FACT; testpoint_1mm5
U1: ATMEGA328P; pvqfn-n32-nopad
U2: MCP73831T-DFN; dfn8-2x3
U3: TPS73233; sot23-5
U4: BLUETOOTH-RN42; roving_rn-42
U5: ADS1291; s-pvqfn-n32-nopad
U6: ADXL362; 16-LGA-3x3.25
Y1: RESONATOR; smd_resonator_1206

Connections:
+3.3V: C5.1, C11.1, C12.1, C20.1, C21.1, C24.1, C25.1, FB1.1, L1.2, P3.2, R3.1, TP2.1, U1.4, U1.6, U3.5, U4.11, U5.23, U6.1, U6.14
+BATT: C4.1, D2.1, P1.1, R1.1, U2.3, U2.4
/AREF: C2.1, U1.20
/AVCC: C1.1, L1.1, U1.18
/Analog front-end/GPIO1: R9.1, U5.26
/Analog front-end/GPIO2: R10.1, U5.25
/Analog front-end/PGA1N: C13.2, U5.1
/Analog front-end/PGA1P: C13.1, U5.2
/Analog front-end/PGA2N: C14.2, U5.7
/Analog front-end/PGA2P: C14.1, U5.8
/Analog front-end/RLDIN: C19.1, R8.1, R12.1, U5.29, U5.30
/Analog front-end/RLDINV: C19.2, R12.2, U5.28
/Analog front-end/VCAP1: C18.1, U5.11
/Analog front-end/VCAP2: C17.1, U5.27
/Analog front-end/VREFP: C15.1, C16.1, U5.9
/BATT_MON: C3.1, R1.2, R2.1, U1.11
/BT_CONN: U1.25, U4.19
/BT_RESET: U1.24, U4.5
/FACTORY_RESET: TP3.1, U4.22
/MCU_RX: U1.30, U4.14
/MCU_TX: U1.31, U4.13
/USER_LED: R7.2, U1.23
/~MCU_CTS: U1.1, U4.15
CH1N: P4.2, U5.3
CH1P: P4.1, U5.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D3.2, MTG1.1, P1.2, P2.5, P2.6, P2.7, P2.8, P2.9, P3.6, R2.2, R5.2, R9.2, R10.2, S2.3, TP1.1, U1.3, U1.5, U1.21, U2.5, U2.9, U3.2, U4.16, U4.28, U4.29, U5.10, U5.13, U5.24, U6.12, U6.13, U6.16, Y1.2
MISO: P3.1, U1.16, U5.21, U6.7
MOSI: P3.4, U1.15, U5.19, U6.6
unnamed: D3.1, R7.1
unnamed: U1.8, Y1.3
unnamed: U1.7, Y1.1
unnamed: R5.1, U2.8
unnamed: C10.1, U3.4
unnamed: S2.2, U3.3
unnamed: R4.2, U2.6
unnamed: D1.2, R4.1
unnamed: C22.1, C23.1
unnamed: U5.5, U5.6, U5.12, U5.31, U5.32
RLD: P4.3, R8.2
SCLK: P3.3, U1.17, U5.20, U6.4
VBUS: C8.1, C9.1, D1.1, D2.2, P2.1, S2.1, U2.1, U2.2, U3.1
XL_INT1: U1.26, U6.11
~AFE_CS: U1.13, U5.18
~AFE_DRDY: U1.32, U5.22
~AFE_PWDN: U1.9, U5.15
~MCU_RESET: P3.5, R3.2, U1.29
~XL_CS: U1.14, U6.8

File hardware/muscleboard/muscleboardv0_BOM.xlsx:

Item Value | Count | Reference | Manufacturer | Distributor | PN | Description | Note
1.5nF | 1 | C19 |  | Digi-Key | 04025C152JAT2A | CAP CER 1500PF 50V 5% X7R 0402
4.7nF | 2 | C13 C14 |  | Digi-Key | CL05B472KB5NNNC | CAP CER 4700PF 50V 10% X7R 0402
0.01uF | 1 | C10 |  | Digi-Key | C0402C103K4RACTU | CAP CER 10000PF 16V 10% X7R 0402 | Need to order
0.1uF | 10 | C1 C2 C3 C5 C15 C20 C21 C9 C23 C25 |  | Digi-Key | CL05A104MP5NNNC | CAP CER 0.1UF 10V 20% X5R 0402
1uF | 4 | C17 C18 C22 C24 |  | Digi-Key | JMK105BJ105KV-F | CAP CER 1UF 6.3V 10% X5R 0402
2.2uF | 1 | C12 |  | Digi-Key | C0402C225M9PACTU | CAP CER 2.2UF 6.3V 20% X5R 0402 | Need to order
4.7uF | 2 | C4 C8 |  | Digi-Key | GRM155R60J475ME47D | CAP CER 4.7UF 6.3V 20% X5R 0402 | Need to order
10uF | 2 | C11 C16 |  | Digi-Key | CL10A106MQ8NNNC | CAP CER 10UF 6.3V 20% X5R 0603
CHG | 1 | D1 |  | Digi-Key | APT1608SGC | LED 1.6X0.8MM 568NM GRN CLR SMD
SCHOTTKY | 1 | D2 |  | Digi-Key | VS-10BQ015-M3/5BT | DIODE SCHOTTKY 15V 1A SMB
RED | 1 | D3 |  | Digi-Key | APT1608SRCPRV | LED 1.6X0.8MM 640NM RED CLR SMD
BLM18PG121SN1 | 1 | FB1 |  | Digi-Key | BLM18PG121SN1D | FERRITE CHIP 120 OHM 2000MA 0603
10uH | 1 | L1 |  | Digi-Key | MLZ1608E100M | INDUCTOR MULTILAYER 10UH 0603
BATT | 1 | P1 |  | Digi-Key | S2B-PH-SM4-TB(LF)(SN) | CONN HEADER PH SIDE 2POS 2MM SMD
USB | 1 | P2 |  | Digi-Key | 690-005-299-043 | CONN MINI USB RCPT RA TYPE B SMD
ICSP | 1 | P3 |  | Digi-Key | 67996-206HLF | CONN HEADER 6POS .100 STR 15AU
2.2k | 2 | R4 R7 |  | Digi-Key | RMCF0402FT2K20 | RES 2.2K OHM 1/16W 1% 0402
10k | 4 | R3 R5 R9 R10 |  | Digi-Key | RMCF0402JT10K0 | RES 10K OHM 1/16W 5% 0402
51k | 1 | R8 |  | Digi-Key | RMCF0402FT51K0 | RES 51K OHM 1/16W 1% 0402
1M | 2 | R2 R12 |  | Digi-Key | RMCF0402JT1M00 | RES 1M OHM 1/16W 5% 0402
2.2M | 1 | R1 |  | Digi-Key | RC1005F225CS | RES 2.2M OHM 1/16W 1% 0402
CHG/ON | 1 | S2 |  | Digi-Key | JS102011SAQN | SWITCH SLIDE 1PDT 6VDC 0.3A SMT
ADS1291 | 1 | U5 |  | Digi-Key | ADS1291IRSMT | IC AFE 24BIT 8KSPS 1CH 32VQFN | Need to order
ATMEGA328P | 1 | U1 |  | Digi-Key | ATMEGA328P-MUR | IC MCU 8BIT 32KB FLASH 32QFN | Need to order
MCP73831T-DFN | 1 | U2 |  | Mouser | MCP73831T-2ACI/MC | Battery Management Charge mgnt contr | Need to order
TPS73233 | 1 | U3 |  | Digi-Key | TPS73233DBVT | IC REG LDO 3.3V 0.25A SOT23-5
BLUETOOTH-RN42 | 1 | U4 |  | Digi-Key | RN42-I/RM | MODULE BLUETOOTH V2.1+EDR | Need to order
ADXL362 | 1 | U6 |  | Digi-Key | ADXL362BCCZ-RL7 | IC ACCEL DIG LO PWR 3AX 16LGA | Need to order
RESONATOR | 1 | Y1 |  | Digi-Key | CSTCE8M00G52-R0 | CER RESONATOR

## KiCad design hardware/brainboard/brainboard_wearable_v2/brainboard_wearable_v2.kicad_pcb

Parts:
MTG1, MTG2, MTG3: MHOLE

Connections:
AGND: MTG1.1, MTG2.1, MTG3.1; also elsewhere on the board

Parts:
C1, C2: 0.1uF
C3: 2.2nF
C4: 0.01uF
R4, R5: 4.7k
U1: MPU6050

Connections:
+3.3V: C1.1, C4.1, R4.1, R5.1, U1.8 (VLOGIC), U1.13 (VDD); also elsewhere on the board
/Brainboard IMU/CPOUT: C3.1, U1.20 (CPOUT)
/Brainboard IMU/REGOUT: C2.1, U1.10 (REGOUT)
AGND: C1.2, C2.2, C3.2, C4.2, U1.1 (CLKIN), U1.9 (AD0), U1.11 (FSYNC), U1.18 (GND); also elsewhere on the board
IMU_INT: U1.12 (INT); also elsewhere on the board
SCL: R4.2, U1.23 (SCL); also elsewhere on the board
SDA: R5.2, U1.24 (SDA); also elsewhere on the board

Parts:
C5, C6, C11, C15, C18, C19, C22, C23: 0.1uF
C7: 1nF
C8: 10uF
C9, C10, C12, C14, C16, C17, C20, C21: 1uF
C13: 100uF
R1, R2: 10K
R3: 499K,0.1%
R6, R7, R19, R20: 10k
SJ1: NO BIAS FILT; SparkFun-Passives-SJ_2S-NO
U2: OPA2376; MSOP8
U3: ADS1299; TQFP_64

Connections:
+2.5V: C5.1, C16.1, C17.1, C18.1, C19.1, C20.1, C22.1, U2.8 (+V), U3.19 (AVDD), U3.21 (AVDD), U3.22 (AVDD), U3.54 (AVDD1), U3.56 (AVDD), U3.59 (AVDD); also elsewhere on the board
+3.3V: C21.1, C23.1, R1.1, R2.1, U3.36 (~RESET), U3.48 (DVDD), U3.50 (DVDD), U3.52 (CLKSEL); also elsewhere on the board
-2.5V: C6.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C18.2, C20.2, C22.2, U2.4 (-V), U3.20 (AVSS), U3.23 (AVSS), U3.25 (VREFN), U3.32 (AVSS), U3.53 (AVSS1), U3.57 (AVSS), U3.58 (AVSS); also elsewhere on the board
/Brainboard AFE/BIASINV: C7.1, R3.2, SJ1.1, U3.61 (BIASINV)
/Brainboard AFE/SRB1: U2.6 (-IN_B), U2.7 (OUT_B), U3.1 (IN8N), U3.3 (IN7N), U3.5 (IN6N), U3.7 (IN5N), U3.9 (IN4N), U3.11 (IN3N), U3.17 (SRB1)
/Brainboard AFE/VCAP1: C13.1, U3.28 (VCAP1)
/Brainboard AFE/VCAP2: C12.1, U3.30 (VCAP2)
/Brainboard AFE/VCAP3: C10.1, C11.1, U3.55 (VCAP3)
/Brainboard AFE/VCAP4: C9.1, U3.26 (VCAP4)
/Brainboard AFE/VREFP: C8.2, U3.24 (VREFP)
/CS: R1.2, U3.39 (~CS); also elsewhere on the board
/DRDY: U3.47 (~DRDY); also elsewhere on the board
/PWDN: R2.2, U3.35 (~PWDN); also elsewhere on the board
AGND: C5.2, C6.2, C14.2, C15.2, C17.2, C19.2, C21.2, C23.2, R6.2, R7.2, R19.2, R20.2, U3.31 (RESV1), U3.33 (DGND), U3.38 (START), U3.41 (DAISY_IN), U3.49 (DGND), U3.51 (DGND), U3.60 (BIASREF); also elsewhere on the board
AIN1N: U3.15 (IN1N); also elsewhere on the board
AIN1P: U3.16 (IN1P); also elsewhere on the board
AIN2N: U3.13 (IN2N); also elsewhere on the board
AIN2P: U3.14 (IN2P); also elsewhere on the board
AIN3P: U3.12 (IN3P); also elsewhere on the board
AIN4P: U3.10 (IN4P); also elsewhere on the board
AIN5P: U3.8 (IN5P); also elsewhere on the board
AIN6P: U3.6 (IN6P); also elsewhere on the board
AIN7P: U3.4 (IN7P); also elsewhere on the board
AIN8P: U3.2 (IN8P); also elsewhere on the board
BIAS: C7.2, R3.1, SJ1.2, U2.3 (+IN_A), U3.62 (BIASIN), U3.63 (BIASOUT); also elsewhere on the board
MISO: U3.43 (DOUT); also elsewhere on the board
MOSI: U3.34 (DIN); also elsewhere on the board
unnamed: R20.1, U3.46 (GPIO4)
unnamed: R19.1, U3.45 (GPIO3)
unnamed: R7.1, U3.44 (GPIO2)
unnamed: R6.1, U3.42 (GPIO1)
REF_IN: U2.5 (+IN_B); also elsewhere on the board
SCLK: U3.40 (SCLK); also elsewhere on the board
SHIELD: U2.1 (OUT_A), U2.2 (-IN_A); also elsewhere on the board

Parts:
C24, C31, C42: 0.1uF
C25, C39, C40, C41: 2.2uF
C26, C29, C36, C37, C38: 10uF
C27, C28, C30, C32: 1uF
C33, C34, C35: 0.01uF
CON1: USB
D1: SMAJ7.0A
D2: BATTLO
D3: PGOOD
D4: CHARGE
F1: PTC 500mA
P1: JST
R8: 562k
R9: 51.1k
R10: 383k
R11, R14, R15, R16: 2.2k
R12: 52.3k
R13: 1.18k
S1: DPDT
TH1: NTC 10K
TP1, TP2: GND
TP3: PREREG
TP4: -3V3
TP5: +2V5
TP6: -2V5
TP8: 3V3
U4: LTC1998
U5: BQ24074(T)
U6: TPS60403
U7: TPS73233
U8: TPS73225
U9: TPS72325

Connections:
+2.5V: C36.1, C39.1, C42.1, TP5.1, U8.5; also elsewhere on the board
+3.3V: C27.1, C32.1, C38.1, C41.1, D2.1 (A), TP8.1, U4.5 (VLOGIC), U6.2 (IN), U7.5, U8.1, U8.3; also elsewhere on the board
+BATT: C24.1, C26.1, R8.1, S1.2, S1.5, U4.1 (BATT), U5.2 (BAT), U5.3 (BAT)
-2.5V: C37.1, C40.1, C42.2, TP6.1, U9.5 (OUT); also elsewhere on the board
-3.3V: C30.1, TP4.1, U6.1 (OUT), U9.2 (IN), U9.3 (EN)
/BATTLO: R11.1, U4.6 (~BATTLO); also elsewhere on the board
/Brainboard Power/B+: F1.2, P1.1
/Brainboard Power/ILIM: R13.1, U5.12 (ILIM)
/Brainboard Power/ISET: R14.1, U5.16 (ISET)
/Brainboard Power/OUT: C29.1, C31.1, R15.1, R16.1, TP3.1, U5.6 (EN1), U5.10 (OUT), U5.11 (OUT), U7.1, U7.3
/Brainboard Power/TMR: R12.1, U5.14 (TMR)
/Brainboard Power/TS: TH1.1, U5.1 (TS)
/Brainboard Power/VBUS: C25.1, CON1.1 (VBUS), D1.2 (K), U5.13 (IN)
/Brainboard Power/_B+: F1.1, S1.1, S1.4
/Brainboard Power/~CHG: D4.2 (K), U5.9 (~CHG)
/Brainboard Power/~PGOOD: D3.2 (K), U5.7 (~PGOOD)
AGND: C24.2, C25.2, C26.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, CON1.5 (GND), CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), D1.1 (A), P1.2 (PM), R10.2, R12.2, R13.2, R14.2, TH1.2, TP1.1, TP2.1, U4.2 (GND), U5.4 (~CE), U5.5 (EN2), U5.8 (VSS), U5.15 (TD/ITERM/SYSOFF), U5.17 (PWPD), U6.4 (GND), U7.2, U8.2, U9.1 (GND); also elsewhere on the board
unnamed: C33.1, U7.4
unnamed: D3.1 (A), R16.2
unnamed: D4.1 (A), R15.2
unnamed: R9.2, R10.1, U4.4 (VHA)
unnamed: R8.2, R9.1, U4.3 (VTHA)
unnamed: D2.2 (K), R11.2
unnamed: C28.2, U6.3 (CFLY-)
unnamed: C28.1, U6.5 (CFLY+)
unnamed: C34.1, U8.4
unnamed: C35.1, U9.4 (NR)

Notes on the sheet:
Battery charger
3.3V regulation
Fast charging current = K_ISET/R_ISET K_ISET = [797..975], 890 typical R_ISET = 2.2k yields 404mA, or 0.4C for 1000mAh cell Input current limit = 500 mA (EN1 = H, EN2 = L)
T_MAXCHG = 10*K_TMR*R_TMR K_TMR = 48s/kOhm R_TMR = 52.3k gives about 7 hr safety cutoff
BATTLO threshold at 3.1V w/ 100mV hysteresis
Low battery detection
Bipolar analog supply generation

Parts:
C43, C45, C47, C48, C49: 0.1uF
C44: 2.2uF
C46: 10uF
P8: CONN_5X2
U10: ATUC3L064

Connections:
+3.3V: C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, P8.4, U10.17 (VDDIN), U10.18 (VDDCORE), U10.34 (ADVREFP), U10.35 (VDDANA), U10.42 (VDDIO), U10.48 (VDDIO); also elsewhere on the board
/BATTLO: U10.26 (PA13); also elsewhere on the board
/Brainboard MCU/RESET_MCU: P8.6, U10.22 (RESET_N)
/Brainboard MCU/TCK: P8.1, U10.11 (PA00)
/Brainboard MCU/TDI: P8.9, U10.4 (PA03)
/Brainboard MCU/TDO: P8.3, U10.13 (PA02)
/Brainboard MCU/TMS: P8.5, U10.14 (PA01)
/CS: U10.6 (PB00); also elsewhere on the board
/DRDY: U10.41 (PA18); also elsewhere on the board
/PWDN: U10.2 (PA09); also elsewhere on the board
AGND: C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, P8.2, P8.10, U10.1 (GND), U10.19 (GND), U10.33 (GNDANA), U10.43 (GND), U10.45 (GND); also elsewhere on the board
IMU_INT: U10.15 (PA07); also elsewhere on the board
MISO: U10.7 (PB02); also elsewhere on the board
MOSI: U10.8 (PB03); also elsewhere on the board
RESET_BT: U10.44 (PB11); also elsewhere on the board
SCL: U10.28 (PA04); also elsewhere on the board
SCLK: U10.16 (PB01); also elsewhere on the board
SDA: U10.12 (PA05); also elsewhere on the board
UARTBT_CTS: U10.29 (PB09); also elsewhere on the board
UARTBT_RTS: U10.32 (PB08); also elsewhere on the board
UARTBT_RX: U10.31 (PB07); also elsewhere on the board
UARTBT_TX: U10.30 (PB06); also elsewhere on the board

Notes on the sheet:
JTAG INTERFACE
MCU uses on-chip oscillator to save board space.
/DRDY on EXTINT[5]
IMU_INT on EXTINT[0]
/BATTLO on EXTINT[2]

Parts:
D5: STAT
D6: CONN
R17, R18: 2.2k
TP7: BTRST
U11: BLUETOOTH-RN42

Connections:
+3.3V: U11.11 (VDD); also elsewhere on the board
/Brainboard Bluetooth/FACTORY: TP7.1, U11.22 (PIO4)
/Brainboard Bluetooth/STATUS: D6.1 (A), U11.19 (PIO2)
/Brainboard Bluetooth/STATUSn: D5.1 (A), U11.21 (PIO5)
AGND: R17.2, R18.2, U11.1 (GND), U11.12 (GND), U11.28 (GND), U11.29 (GND); also elsewhere on the board
unnamed: D6.2 (K), R18.1
unnamed: D5.2 (K), R17.1
RESET_BT: U11.5 (RESET); also elsewhere on the board
UARTBT_CTS: U11.15 (UARTRTS); also elsewhere on the board
UARTBT_RTS: U11.16 (UARTCTS); also elsewhere on the board
UARTBT_RX: U11.14 (UARTTX); also elsewhere on the board
UARTBT_TX: U11.13 (UARTRX); also elsewhere on the board

Notices in the files:
firmware/at32uc3l064/brainboard_fw/brainboard_fw/src/main.c:
All Atmel Software Framework libraries used herein are copyright Atmel and
subject to their appropriate licenses, which allow free redistribution with
Brainboard firmware code is placed under the MIT license
Copyright (c) 2014 Graham Kelly
